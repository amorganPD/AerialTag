# IAR project lib_board_lpcxpresso_54102_m0.ewp, settings and files
configuration nxp_lpcxpresso_54102_m0 (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M0PL NXP LPC54102J512_M0PL
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_lpcxpresso_54102_m0
    ./: board.c board_sysinit.c
