# IAR project lib_board_lpcxpresso_54102.ewp, settings and files
configuration lpcxpresso_54102 (ARM)
  General.OGChipSelectEditMenu: LPC4325_M4 NXP LPC4325_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102; C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_chip\chip_5410x; C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_chip\chip_common; C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_chip\chip_5410x\config; C:\Users\amorgan\Documents\NXP\software; C:\Users\amorgan\Documents\NXP\software\CMSIS\CMSIS\Include; C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_board\board_common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_lpcxpresso_54102
    ./: board.c board_sysinit.c
