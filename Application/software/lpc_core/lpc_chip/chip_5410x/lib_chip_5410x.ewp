# IAR project lib_chip_5410x.ewp, settings and files
configuration chip_5410x_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC4325_M4 NXP LPC4325_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: C:\Users\amorgan\Documents\NXP; C:\Users\amorgan\Documents\NXP\software\CMSIS\CMSIS\Include; C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102; C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_chip\chip_common; C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_chip\chip_5410x; C:\Users\amorgan\Documents\NXP\software\lpc_core\lpc_chip\chip_5410x\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_110x.out
  group csp
    ./: chip_5410x.c clock_5410x.c crc_5410x.c fifo_5410x.c gpio_5410x.c gpiogroup_5410x.c hw_adc.c hw_dmaaltd.c hw_dmaaltd_rom_api.c hw_i2cmd.c hw_i2cmd_rom_api.c hw_i2cmond.c hw_i2cmond_rom_api.c hw_i2csd.c hw_i2csd_rom_api.c hw_spimd.c hw_spimd_rom_api.c hw_spisd.c hw_spisd_rom_api.c hw_uart.c iocon_5410x.c pinint_5410x.c pll_5410x.c ritimer_5410x.c romapi_adc.c romapi_dma.c romapi_i2cm.c romapi_i2cmon.c romapi_i2cs.c romapi_spim.c romapi_spis.c romapi_uart.c rtc_5410x.c sct_5410x.c sct_pwm_5410x.c stopwatch_5410x.c syscon_5410x.c sysinit_5410x.c timer_5410x.c utick_5410x.c wwdt_5410x.c
    ../chip_common/: fpu_init.c iap.c ring_buffer.c rtc_ut.c
  group libs
    power_lib/iar/: lib_power.a
