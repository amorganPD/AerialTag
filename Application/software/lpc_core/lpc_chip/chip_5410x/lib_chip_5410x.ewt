<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>chip_5410x_lib</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>csp</name>
    <file>
      <name>$PROJ_DIR$\chip_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\clock_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\crc_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\fifo_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\chip_common\fpu_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\gpio_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\gpiogroup_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_dmaaltd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_dmaaltd_rom_api.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_i2cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_i2cmd_rom_api.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_i2cmond.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_i2cmond_rom_api.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_i2csd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_i2csd_rom_api.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_spimd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_spimd_rom_api.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_spisd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_spisd_rom_api.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hw_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\chip_common\iap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\iocon_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\pinint_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\pll_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\chip_common\ring_buffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ritimer_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\romapi_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\romapi_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\romapi_i2cm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\romapi_i2cmon.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\romapi_i2cs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\romapi_spim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\romapi_spis.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\romapi_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rtc_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\chip_common\rtc_ut.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sct_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sct_pwm_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stopwatch_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\syscon_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sysinit_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\timer_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\utick_5410x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\wwdt_5410x.c</name>
    </file>
  </group>
  <group>
    <name>libs</name>
    <file>
      <name>$PROJ_DIR$\power_lib\iar\lib_power.a</name>
    </file>
  </group>
</project>


